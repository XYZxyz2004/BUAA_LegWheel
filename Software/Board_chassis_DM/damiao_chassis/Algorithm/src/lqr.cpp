/**
 *******************************************************************************
 * @file      : lqr.cpp
 * @brief     :
 * @history   :
 *  Version     Date            Author          Note
 *  V0.9.0      yyyy-mm-dd      <author>        1. <note>
 *******************************************************************************
 * @attention :
 *******************************************************************************
 *  Copyright (c) 2024 Reborn Team, USTB.
 *  All Rights Reserved.
 *******************************************************************************
 */
/* Includes ------------------------------------------------------------------*/
#include "lqr.h"
#include "string.h"
#include "stdint.h"
/* Private macro -------------------------------------------------------------*/
/* Private constants ---------------------------------------------------------*/
/* Private types -------------------------------------------------------------*/
/* Private variables ---------------------------------------------------------*/


//接触地面时的运动控制反馈增益矩阵
//Q_cost=diag([10 10 50 100 2000 50]);
//R_cost=diag([3, 0.25]);
const float k[12][3] = {
 71.8592  ,-71.2999   ,-4.6511,
    5.1823 ,  -5.7677 ,  -0.7699,
   14.9846 , -12.1202 ,  -1.2991,
   23.3550 , -19.0412  , -2.8293,
   57.3040,  -72.4400  , 29.5836,
   11.4332,  -14.5591 ,   6.4758,
  -25.0464 , -31.7654,   30.7532,
   14.3009,  -16.4702 ,   5.9736,
   17.3607,  -28.2315 ,  12.9278,
   44.7741,  -58.7815 ,  23.8196,
 -359.2348,  288.1754 ,  24.0029,
  -77.7661 ,  62.9795 ,   1.1083

};


//离地时的运动控制反馈增益矩阵，用于保持腿部姿态数值
//Q_cost=diag([150 120 50 100 2000 10]);
//R_cost=diag([3, 0.25]);
const float k_off[12][3] = {
  78.3842  ,-90.2246  , -6.1098,
   14.5843 , -16.0068 ,  -1.1386,
    6.1225 ,  -7.6588 ,  -1.2104,
    9.6270  ,-12.6927 ,  -3.1181,
    6.1421  ,-33.0630 ,  27.6002,
    5.7224 ,  -7.9641 ,   4.8393,
 -308.6635  ,144.4340 ,  37.0922,
  -38.4600 ,   6.1753 ,  14.1760,
  -33.4331 ,  10.6790 ,   7.8654,
  -47.6603 ,   6.8157 ,  18.1762,
 -169.7266 , 193.4008 ,  22.7714,
  -23.1479,   27.0878 ,  -0.1773
};
/* External variables --------------------------------------------------------*/
/* Private function prototypes -----------------------------------------------*/

void Lqr::Calc() {
  float lsqr = leg_len_ * leg_len_;
  if (F_N_ > 10.0f)
{
  for (uint8_t i = 0; i < 2; ++i)
		{
    uint8_t j = i * 6;
    T_K_[i][0] =
        (k[j + 0][0] * lsqr + k[j + 0][1] * leg_len_ + k[j + 0][2]) * -theta_;
    T_K_[i][1] =
        (k[j + 1][0] * lsqr + k[j + 1][1] * leg_len_ + k[j + 1][2]) * -w_theta_;
    T_K_[i][2] =
        (k[j + 2][0] * lsqr + k[j + 2][1] * leg_len_ + k[j + 2][2]) *(target_dist_- dist_);
    T_K_[i][3] = (k[j + 3][0] * lsqr + k[j + 3][1] * leg_len_ + k[j + 3][2]) *
                 (target_speed_ -speed_);
    T_K_[i][4] =
        (k[j + 4][0] * lsqr + k[j + 4][1] * leg_len_ + k[j + 4][2]) *- phi_;
    T_K_[i][5] =
        (k[j + 5][0] * lsqr + k[j + 5][1] * leg_len_ + k[j + 5][2]) * -w_phi_;
		}
	
}
else if (F_N_ <=10.0f) 
{
    for (uint8_t i = 0; i < 6; ++i)
		{
      T_K_[0][i] = 0.0f;
    };
    T_K_[1][2] = T_K_[1][3] = T_K_[1][4] = T_K_[1][5] = 0.0f;
		T_K_[1][0]=(k_off[6][0]*lsqr+k_off[6][1]*leg_len_+k_off[6][2])* -theta_;
		T_K_[1][1]=(k_off[7][0]*lsqr+k_off[7][1]*leg_len_+k_off[7][2]) * -w_theta_;
	
}
 for (uint8_t i = 0; i < 2; ++i) 
	{
    T_[i] = T_K_[i][0] + T_K_[i][1] + T_K_[i][2] + T_K_[i][3] + T_K_[i][4] +
            T_K_[i][5];
  }
 
}