/**
 *******************************************************************************
 * @file      : lqr.cpp
 * @brief     :
 * @history   :
 *  Version     Date            Author          Note
 *  V0.9.0      yyyy-mm-dd      <author>        1. <note>
 *******************************************************************************
 * @attention :
 *******************************************************************************
 *  Copyright (c) 2024 Reborn Team, USTB.
 *  All Rights Reserved.
 *******************************************************************************
 */
/* Includes ------------------------------------------------------------------*/
#include "lqr.h"
#include "string.h"
#include "stdint.h"
/* Private macro -------------------------------------------------------------*/
/* Private constants ---------------------------------------------------------*/
/* Private types -------------------------------------------------------------*/
/* Private variables ---------------------------------------------------------*/


//接触地面时的运动控制反馈增益矩阵
// Q_cost=diag([50 150 50 120 10 10 10 10 2500 50]);
//R_cost=diag([3 3 0.25 0.25]);
const float k[40][3] = {
   10.3937  , -7.8219  , -1.8932,
   18.8949 , -14.2320 ,  -4.4268,
   -2.5623 ,   1.2407 ,  -3.0662,
   -4.0454 ,   2.0393 ,  -4.8244,
   39.7177 , -41.7356 ,  -3.5090,
    3.7032 ,  -3.5763,   -1.0849,
   37.1716 , -30.1739 ,  -3.1248,
    1.8773 ,  -2.0301 ,  -0.1530,
   89.9449 , -89.1244 ,  28.4413,
   13.5310 , -13.6765 ,   4.6692,
   10.3937 ,  -7.8219 ,  -1.8932,
   18.8949 , -14.2320 ,  -4.4268,
    2.5623 ,  -1.2407 ,   3.0662,
    4.0454 ,  -2.0393 ,   4.8244,
   37.1716 , -30.1739 ,  -3.1248,
    1.8773 ,  -2.0301 ,  -0.1530,
   39.7177 , -41.7356 ,  -3.5090,
    3.7032 ,  -3.5763 ,  -1.0849,
   89.9449 , -89.1244 ,  28.4413,
   13.5310 , -13.6765 ,   4.6692,
   21.6942 , -23.5046 ,   7.8830,
   54.5331,  -55.1047 ,  17.3391,
   11.9962 ,  -5.9804 ,  -4.5676,
   18.5495 ,  -9.9789 ,  -7.1729,
   30.5851,   19.8075 ,  15.1706,
   18.3219 ,  -9.6973 ,   5.2536,
   -6.9188,  -71.4322 ,  10.7132,
    0.0778,   -8.2186 ,   0.1478,
 -254.6502,  189.5154,   37.8443,
  -40.2791,   30.2630 ,   4.4732,
   21.6942,  -23.5046 ,   7.8830,
   54.5331,  -55.1047 ,  17.3391,
  -11.9962,    5.9804 ,   4.5676,
  -18.5495,    9.9789 ,   7.1729,
   -6.9188,  -71.4322 ,  10.7132,
    0.0778,   -8.2186,    0.1478,
   30.5851 ,  19.8075,   15.1706,
   18.3219,   -9.6973 ,   5.2536,
 -254.6502,  189.5154 ,  37.8443,
  -40.2791,  30.2630  ,  4.4732
};


//离地时的运动控制反馈增益矩阵，用于保持腿部姿态数值
//Q_cost=diag([10 10 10 10 150 100 150 100 2000 50]);
//R_cost=diag([3, 0.25]);
const float k_off[40][3] = {
	   3.2844 ,  -3.2283 ,  -0.6244,
    5.2387 ,  -5.2183  , -1.8724,
   -0.3181 ,   1.1097  , -1.4659,
   -0.1302 ,   1.1396  , -1.5775,
   41.0042 , -49.4837  , -3.8177,
   19.3640 , -18.4909  , -1.7323,
   42.2754 , -33.1136  , -1.9448,
    4.5165 ,  -3.6472  , -0.0540,
   24.5289 , -43.2994  , 23.0339,
    5.0354 ,  -8.0734  ,  4.2161,
    3.2844 ,  -3.2283  , -0.6244,
    5.2387 ,  -5.2183  , -1.8724,
    0.3181 ,  -1.1097  ,  1.4659,
    0.1302 ,  -1.1396  ,  1.5775,
   42.2754 , -33.1136  , -1.9448,
    4.5165 ,  -3.6472  , -0.0540,
   41.0042 , -49.4837  , -3.8177,
   19.3640 , -18.4909  , -1.7323,
   24.5289 , -43.2994  , 23.0339,
    5.0354 ,  -8.0734  ,  4.2161,
   -6.8273 ,   0.6273  ,  2.2480,
   -4.6361 ,  -6.5789  ,  6.5689,
    4.3911 ,  -5.5391  , -1.7343,
    4.1920 ,  -6.2685  , -1.8559,
  -78.8307 ,  66.7798  , 20.7618,
  -28.4593 ,   6.6597  , 13.5093,
  -58.2278 , -23.7493  ,  5.8598,
    6.4283 , -12.9997  ,  0.2296,
 -154.7755 , 142.6425  , 24.0669,
  -26.3096,   24.3913  ,  3.8940,
   -6.8273 ,   0.6273  ,  2.2480,
   -4.6361 ,  -6.5789  ,  6.5689,
   -4.3911 ,   5.5391  ,  1.7343,
   -4.1920 ,   6.2685  ,  1.8559,
  -58.2278 , -23.7493  ,  5.8598,
    6.4283 , -12.9997  ,  0.2296,
  -78.8307 ,  66.7798  , 20.7618,
  -28.4593 ,   6.6597  , 13.5093,
 -154.7755 , 142.6425  , 24.0669,
  -26.3096 ,  24.3913  ,  3.8940

};
/* External variables --------------------------------------------------------*/
/* Private function prototypes -----------------------------------------------*/

void Lqr::Calc() {
  float lsql = leg_len_l_ * leg_len_l_;
	float lsqr = leg_len_r_ * leg_len_r_;

  for (uint8_t i = 0; i < 4; ++i)
		{
		if(i==0||i==2)
		{
    uint8_t j = i * 10;
    T_K_[i][0] =
        (k[j + 0][0] * lsql + k[j + 0][1] * leg_len_l_ + k[j + 0][2]) * (target_dist_- dist_);
    T_K_[i][1] =
        (k[j + 1][0] * lsql + k[j + 1][1] * leg_len_l_ + k[j + 1][2]) * (target_speed_ -speed_);
    T_K_[i][2] =
        (k[j + 2][0] * lsql + k[j + 2][1] * leg_len_l_ + k[j + 2][2]) *(target_rotation_- rotation_);
    T_K_[i][3] = 
				(k[j + 3][0] * lsql + k[j + 3][1] * leg_len_l_ + k[j + 3][2]) *(target_w_rotation_ -w_rotation_);
    T_K_[i][4] =
        (k[j + 4][0] * lsql + k[j + 4][1] * leg_len_l_ + k[j + 4][2]) *- theta_l_;
    T_K_[i][5] =
        (k[j + 5][0] * lsql + k[j + 5][1] * leg_len_l_ + k[j + 5][2]) * -w_theta_l_;
		T_K_[i][6] =
        (k[j + 6][0] * lsql + k[j + 6][1] * leg_len_l_ + k[j + 6][2]) *- theta_r_;
    T_K_[i][7] =
        (k[j + 7][0] * lsql + k[j + 7][1] * leg_len_l_ + k[j + 7][2]) * -w_theta_r_;
		T_K_[i][8] =
        (k[j + 8][0] * lsql + k[j + 8][1] * leg_len_l_ + k[j + 8][2]) *- body_;
    T_K_[i][9] =
        (k[j + 9][0] * lsql + k[j + 9][1] * leg_len_l_ + k[j + 9][2]) * -w_body_;
		}
		else
		{
			    uint8_t j = i * 10;
    T_K_[i][0] =
        (k[j + 0][0] * lsqr + k[j + 0][1] * leg_len_r_ + k[j + 0][2]) * (target_dist_- dist_);
    T_K_[i][1] =
        (k[j + 1][0] * lsqr + k[j + 1][1] * leg_len_r_ + k[j + 1][2]) * (target_speed_ -speed_);
    T_K_[i][2] =
        (k[j + 2][0] * lsqr + k[j + 2][1] * leg_len_r_ + k[j + 2][2]) *(target_rotation_- rotation_);
    T_K_[i][3] = 
				(k[j + 3][0] * lsqr + k[j + 3][1] * leg_len_r_ + k[j + 3][2]) *(target_w_rotation_ -w_rotation_);
    T_K_[i][4] =
        (k[j + 4][0] * lsqr + k[j + 4][1] * leg_len_r_ + k[j + 4][2]) *- theta_l_;
    T_K_[i][5] =
        (k[j + 5][0] * lsqr + k[j + 5][1] * leg_len_r_ + k[j + 5][2]) * -w_theta_l_;
		T_K_[i][6] =
        (k[j + 6][0] * lsqr + k[j + 6][1] * leg_len_r_ + k[j + 6][2]) *- theta_r_;
    T_K_[i][7] =
        (k[j + 7][0] * lsqr + k[j + 7][1] * leg_len_r_ + k[j + 7][2]) * -w_theta_r_;
		T_K_[i][8] =
        (k[j + 8][0] * lsqr + k[j + 8][1] * leg_len_r_ + k[j + 8][2]) *- body_;
    T_K_[i][9] =
        (k[j + 9][0] * lsqr + k[j + 9][1] * leg_len_r_ + k[j + 9][2]) * -w_body_;
		}
		}
if(F_N_L_<15.0f)
{
	for(int k=0;k<=3;k++)
	{
		T_K_[0][k]=0;
	}
		for(int k=8;k<=9;k++)
	{
		T_K_[0][k]=0;
	}
	for(int k=0;k<=3;k++)
	{
		T_K_[2][k]=0;
	}
		for(int k=8;k<=9;k++)
	{
		T_K_[2][k]=0;
	}
	 T_K_[0][4] =
        (k_off[4][0] * lsql +k_off[4][1] * leg_len_l_ + k_off[4][2]) *- theta_l_;
   T_K_[0][5] =
        (k_off[5][0] * lsql +k_off[5][1] * leg_len_l_ + k_off[5][2]) *-w_theta_l_;
	 T_K_[0][6] =
        (k_off[6][0] * lsql +k_off[6][1] * leg_len_l_ + k_off[6][2]) *- theta_r_;
   T_K_[0][7] =
        (k_off[7][0] * lsql +k_off[7][1] * leg_len_l_ + k_off[7][2]) *-w_theta_r_;
	 T_K_[2][4] =
        (k_off[24][0] * lsql +k_off[24][1] * leg_len_l_ + k_off[24][2]) *- theta_l_;
   T_K_[2][5] =
        (k_off[25][0] * lsql +k_off[25][1] * leg_len_l_ + k_off[25][2]) *-w_theta_l_;
	 T_K_[2][6] =
        (k_off[26][0] * lsql +k_off[26][1] * leg_len_l_ + k_off[26][2]) *- theta_r_;
   T_K_[2][7] =
        (k_off[27][0] * lsql +k_off[27][1] * leg_len_l_ + k_off[27][2]) *-w_theta_r_;
}	

if(F_N_R_<15.0f)
{
	for(int k=0;k<=3;k++)
	{
		T_K_[1][k]=0;
	}
		for(int k=8;k<=9;k++)
	{
		T_K_[1][k]=0;
	}
	for(int k=0;k<=3;k++)
	{
		T_K_[3][k]=0;
	}
		for(int k=8;k<=9;k++)
	{
		T_K_[3][k]=0;
	}
	T_K_[1][4] =
        (k_off[14][0] * lsqr +k_off[14][1] * leg_len_r_ + k_off[14][2]) *- theta_l_;
  T_K_[1][5] =
        (k_off[15][0] * lsqr + k_off[15][1] * leg_len_r_ + k_off[15][2]) * -w_theta_l_;
	T_K_[1][6] =
        (k_off[16][0] * lsqr +k_off[16][1] * leg_len_r_ + k_off[16][2]) *- theta_r_;
  T_K_[1][7] =
        (k_off[17][0] * lsqr + k_off[17][1] * leg_len_r_ +k_off[17][2]) * -w_theta_r_;
	T_K_[3][4] =
        (k_off[34][0] * lsqr +k_off[34][1] * leg_len_r_ + k_off[34][2]) *- theta_l_;
  T_K_[3][5] =
        (k_off[35][0] * lsqr + k_off[35][1] * leg_len_r_ + k_off[35][2]) * -w_theta_l_;
	T_K_[3][6] =
        (k_off[36][0] * lsqr +k_off[36][1] * leg_len_r_ + k_off[36][2]) *- theta_r_;
  T_K_[3][7] =
        (k_off[37][0] * lsqr + k_off[37][1] * leg_len_r_ +k_off[37][2]) * -w_theta_r_;
}
 for (uint8_t i = 0; i < 4; ++i) 
	{
    T_[i] = T_K_[i][0] + T_K_[i][1] + T_K_[i][2] + T_K_[i][3] + T_K_[i][4] +T_K_[i][5]+T_K_[i][6]+T_K_[i][7]+T_K_[i][8]+T_K_[i][9];
  }
 
}